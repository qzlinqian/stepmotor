# Keil uVision project motor.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: motor +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD USE_STDPERIPH_DRIVER
  c include: ..\motor\CMSIS;..\motor\USER;..\motor\FWLib\inc;..\motor\FWLib\src;..\motor\HARDWARE\inc;..\motor\HARDWARE\src;..\..\test\copy\inc;..\motor\HARDWARE\inc;..\motor\HARDWARE\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMCSIS
    ../motor/CMSIS/: core_cm3.c
  group FWLib
    ../motor/FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_wwdg.c
  group USR
    ../../test/copy/inc/: main.c stepmotor.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6, Device:Startup 1.0.0
